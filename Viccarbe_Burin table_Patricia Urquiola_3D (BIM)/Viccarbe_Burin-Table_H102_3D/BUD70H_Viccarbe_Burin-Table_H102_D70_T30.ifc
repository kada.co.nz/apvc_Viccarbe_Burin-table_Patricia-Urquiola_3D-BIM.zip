Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: 0001
Time: 2020-12-21T17:05:21
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.20.24
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Dec 21 17:05:21 2020 * Host: MSI * Database: C:\Users\info\AppData\Local\Temp\{89DCB920-4E25-430E-BC8E-BC7F5F072FB7}\ifc * Database version: 5507 * Database creation date: Mon Dec 21 17:05:21 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Dec 21 17:05:21 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Dec 21 17:05:21 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head

# IfcFurnishingElement: 1020 x 700 x 700 mm, 2019-EN_Furniture_Viccarbe_Burin-Table_BUD70H:1020 x 700 x 700 mm:289432
In: Level 1
Type - ElementType: 1020 x 700 x 700 mm; Material: Viccarbe - Polyethylene Black RAL 9005, Viccarbe - MDF Black RAL 9005
Type - Data - Is External: no; Nominal Depth: 700 mm; Nominal Height: 1020 mm; Nominal Length: 700 mm; Seating Height: 0 mm; Work Surface Area: 0.384845 m2
Type - Dimensions - Depth: 700 mm; Height: 1020 mm; Radius: 350 mm; Width: 700 mm
Type - General - Maintenance Cost: 0; Is Extended Warranty: no
Type - Green Building Properties - Atmospheric Acidification Per Unit: 0; Climate Change Per Unit: 0; Energy Spent: 0; Eutrophication Per Unit: 0; Hazardous Waste Per Unit: 0; Inert Waste Per Unit: 0; NonHazardous Waste Per Unit: 0; Non Renewable Energy Consumption Per Unit: 0; Photochemical Ozone Formation Per Unit: 0; Radioactive Waste Per Unit: 0; Renewable Energy Consumption Per Unit: 0; Resource Depletion Per Unit: 0; Stratospheric Ozone Layer Destruction Per Unit: 0; Total Primary Energy Consumption Per Unit: 0; Unit: Individual Unit; Water Consumption Per Unit: 0
Type - Identity Data - CE Mark: no; Article Number: BUD70H; Author: Bimetica Parametric Design Services S.L.; BIM Content Download Platform: www.bimetica.com; BIM Eelement Expiry Date: 21/12/2021; BIM Element Issue Date: 21/12/2020; BIM Profile URL: https://bimetica.com/en/bim-object-viccarbe-burin-table-h102-d70-budh70h-9223.html; BIMsupport: https://bimsupport.info/es/fabricantes/viccarbe-habitat-bim/; Code: BUD70H; Contact Email: info@viccarbe.com; Country of Sale: Internacional; Description: Table; GDO-BIM Standard Version: GDO-BIM V02; History: (RVT2019) Creation of Element.; License Number: XXX-XXXX9536; Manufacturer: Viccarbe Habitat S.L.; Measuring Unit: Individual Unit; Model: Burin Table H102 D70 - BUDH70H; Model Label: Burin Table H102 D70 - BUDH70H; OmniClass Number: 23.40.20.00; OmniClass Title: General Furniture and Specialties; Owner: Viccarbe Habitat S.L.; Production Year: 2018; Product URL: https://www.viccarbe.com/model/burin-table/; Reference: BUD70H; Series: Burin Table; Technical Information: https://www.viccarbe.com/download/public/Viccarbe-BURIN_Patricia-Urquiola_EN.pdf; Technical Support Contact: datadevelopment@viccarbe.com; Telephone Contact: 0034 961 20 10 10; Type Name: 1020 x 700 x 700 mm; URL: www.viccarbe.com; Version: RVT2019
Type - Materials and Finishes - Material: Viccarbe - Polyethylene Black RAL 9005; Table Top: Viccarbe - MDF Black RAL 9005
Type - Other - Category: Furniture; Family Name: 2019-EN_Furniture_Viccarbe_Burin-Table_BUD70H
Pset_ManufacturerTypeInformation - ArticleNumber: BUD70H; ModelLabel: Burin Table H102 D70 - BUDH70H; Manufacturer: Viccarbe Habitat S.L.; ProductionYear: 2018
Viccarbe Furniture Data - Model: Burin Table H102 D70 - BUDH70H; Type: 2019-EN_Furniture_Viccarbe_Burin-Table_BUD70H: 1020 x 700 x 700 mm; Author: Bimetica Parametric Design Services S.L.; Owner: Viccarbe Habitat S.L.; License Number: XXX-XXXX9536; Version: RVT2019; BIM Element Issue Date: 21/12/2020; BIM Eelement Expiry Date: 21/12/2021; GDO-BIM Standard Version: GDO-BIM V02; BIM Content Download Platform: www.bimetica.com; IfcExportAs: IfcFurniture; IfcExportType: Table; COBie Category: IfcFurniture; OmniClass Number: 23.40.20.00; OmniClass Title: Residential Tables; Omniclass Code: 23-21 23 15; Omniclass Title: Residential Tables; Masterformat Code: 12 58 23; Masterformat Title: Coffee Tables; Uniclass2015 Code: 40-50-21; Uniclass2015 Title: Desks, tables and worktops; UNSPSC Code: 56101519; UNSPSC Title: Tables; Gubimclass Code: 60.20.30.20; Gubimclass Title: Sillas y Sofás; Material: Viccarbe - Polyethylene Black RAL 9005; Description: Table; URL: www.viccarbe.com; Is External: no; Height: 1020 mm; Width: 700 mm; Depth: 700 mm; Work Surface Area: 0.384845 m2; Reference: BUD70H; Manufacturer: Viccarbe Habitat S.L.; Product URL: https://www.viccarbe.com/model/burin-table/; Technical Information: https://www.viccarbe.com/download/public/Viccarbe-BURIN_Patricia-Urquiola_EN.pdf; Article Number: BUD70H; Series: Burin Table; Model Label: Burin Table H102 D70 - BUDH70H; Production Year: 2018; BIM Profile URL: https://bimetica.com/en/bim-object-viccarbe-burin-table-h102-d70-budh70h-9223.html; Technical Support Contact: datadevelopment@viccarbe.com; BIMsupport: https://bimsupport.info/es/fabricantes/viccarbe-habitat-bim/; Telephone Contact: 0034 961 20 10 10; Contact Email: info@viccarbe.com; Country of Sale: Internacional; CE Mark: no; Code: BUD70H; Measuring Unit: Individual Unit; Maintenance Cost: 0; Is Extended Warranty: no; Unit: Individual Unit
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 1.08307 m2; Volume: 0.0926603 m3
Other - Family: 2019-EN_Furniture_Viccarbe_Burin-Table_BUD70H: 1020 x 700 x 700 mm; Family and Type: 2019-EN_Furniture_Viccarbe_Burin-Table_BUD70H: 1020 x 700 x 700 mm; Type: 2019-EN_Furniture_Viccarbe_Burin-Table_BUD70H: 1020 x 700 x 700 mm; Type Id: 2019-EN_Furniture_Viccarbe_Burin-Table_BUD70H: 1020 x 700 x 700 mm
Phasing - Phase Created: Phase 1
